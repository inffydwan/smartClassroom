# Keil uVision project STM32F429.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO
  c include: ..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\BSP\LED;..\BSP\Key;..\BSP\EXIT;..\BSP\UART;..\BSP\DMA_UART;..\BSP\I2C_EE;..\BSP\SPI_FLASH;..\BSP\RTC;..\BSP\RCC;..\BSP\SDRAM;..\BSP\LCD;..\BSP\ADC;..\BSP\TIMER;..\BSP\TouchKey;..\BSP\Beeper;..\BSP\IWDG;..\BSP\WWDG;..\FATFS;..\BSP\I2C_Touch;..\STemWin\Config;..\STemWin\inc;..\STemWin_Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_spi.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_rng.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_crc.c
  group USER
    ../User/: main.c stm32f4xx_it.c
  group BSP
    ../BSP/LED/: led.c
    ../BSP/Key/: key.c touchKey.c
    ../BSP/EXIT/: exti.c
    ../BSP/UART/: uart.c
    ../BSP/DMA_UART/: dma_uart.c
    ../BSP/I2C_EE/: i2c_ee.c
    ../BSP/SPI_FLASH/: spi_flash.c
    ../BSP/RTC/: rtc.c
    ../BSP/SDRAM/: sdram.c
    ../BSP/RCC/: rcc.c
    ../BSP/LCD/: lcd.c
    ../BSP/ADC/: adc.c
    ../BSP/TIMER/: timer.c advancedTimer.c
    ../BSP/Beeper/: beeper.c
    ../BSP/IWDG/: iwdg.c
    ../BSP/WWDG/: wwdg.c
    ../BSP/I2C_Touch/: i2c_touch.c
  group DOC
    ../Doc/: readMe.txt
  group FATFS
    ../FATFS/: diskio.c ff.c
    ../FATFS/option/: cc936.c
  group STemWin
    ../STemWin/OS/: GUI_X.c
    ../STemWin/Lib/: STemWin_CM4_wc16_ot_ARGB.a
    ../STemWin/Config/: GUIConf.c GUIConf.h GUIDRV_wf.c
  group STemWin/Task
    ../STemWin_Task/: MainTask.c
